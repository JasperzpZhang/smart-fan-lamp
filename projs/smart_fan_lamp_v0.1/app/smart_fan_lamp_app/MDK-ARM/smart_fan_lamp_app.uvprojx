# Keil uVision project smart_fan_lamp_app.uvprojx, settings and files
target smart_fan_lamp_app (5060960::V5.06 update 7 (build 960)::.\ARM_Complier_5.06)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: smart_fan_lamp_app +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../src/arm
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group lib
    ../../src/arm/lib/cli/: lib_cli.c lib_cli_custom.c
    ../../src/arm/lib/debug/: lib_debug.c lib_debug_uart.c
    ../../src/arm/lib/uart/: lib_uart.c
    ../../src/arm/lib/wdog/: lib_wdog.c
    ../../src/arm/lib/tim/: lib_tim.c
    ../../src/arm/lib/rbuf/: lib_rbuf.c lib_rbuf_internal.c
    ../../src/arm/lib/exti/: lib_exti.c
    ../../src/arm/lib/iic/: lib_iic.c
    ../../src/arm/lib/delay/: lib_delay.c
  group drv
    ../../src/arm/drv/peri/mem/: drv_mem.c drv_mem_fram.c drv_mem_spi_flash.c drv_mem_spi_flash_if.c drv_mem_stm32_flash_if.c
    ../../src/arm/drv/peri/tp/: drv_tp.c
    ../../src/arm/drv/peri/rtc/: drv_rtc.c drv_rtc_ds1338.c
    ../../src/arm/drv/peri/humiture/: drv_aht30.c
    ../../src/arm/drv/peri/sc/lcd_1in83/: drv_lcd_1in83.c drv_lcd_1in83_cfg.c drv_cst816t.c drv_cst816t_if.c
  group app
    ../../src/arm/app/: app.c sys.c
    ../../src/arm/app/svc/: cli.c voice.c led.c fan.c wave.c panel.c mem.c data.c tp.c time.c
software components: CMSIS:CORE 4.3.0
